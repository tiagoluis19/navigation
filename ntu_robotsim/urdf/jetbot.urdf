Commit message: fixed camera orientation

File: ntu_robotsim/urdf/jetbot.urdf (robot description, URDF)
Before this commit: robot jetbot, 3 links, 2 joints
Joints:
- joint base_to_camera: origin xyz=0.1 0.0 0.19 rpy=0 0 0 -> xyz=0.1 0.0 0.19 rpy=-1.57 0.0 -1.57
